# Keil uVision project Project.uvprojx, settings and files
target stm32_template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0xC0000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_template +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL, USE_STM3210B_EVAL, MAINBOARD_V4
  c misc: --cpp11
  c include: .\src;.\src\stm32f10x_std\inc;.\src\user;.\src\core;.\src\config;.\src\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group stm32f10x_std
    ./src/stm32f10x_std/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group stm32f10x_startup
    ./src/stm32f10x_startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
  group user
    ./src/user/: main.cpp
  group core
    ./src/core/: gpio.cpp uart.cpp
  group config
    ./src/config/: gpio_config.cpp uart_config.cpp led_config.cpp
  group lib
    ./src/lib/: led.cpp
